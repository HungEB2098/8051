# Keil uVision project LCD16x2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD16x2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/Users/Autumn/Downloads/Bai018/Lib/: Delay.c LCD4.c
    ./: main.c
